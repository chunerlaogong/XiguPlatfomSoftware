# IAR project BerthPo_NBBC95B5.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: DEBUG; STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\..\..\SOURCE\App; ..\..\..\SOURCE\Kernel\Bsp\Stm8\include; ..\..\..\SOURCE\Libraries\include; ..\..\..\SOURCE\Kernel\Drivers\include; ..\..\..\SOURCE\Kernel\Bsp\Stm8\STM8L15x_StdPeriph_Driver\inc; ..\..\..\SOURCE\App\BerthPo_NBBC95B5\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BerthPo_NBBC95B5.srec
  ILINK.IlinkOutputFile: BerthPo_NBBC95B5.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l151c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x10
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
  ILINK.IlinkIcfFile: linker\lnkstm8l151c8.icf
  group APP/BerthPo_NBBC95B5/src
    ../../../SOURCE/App/BerthPo_NBBC95B5/src/: BerthPo_BottomValAdjustAdaptive.c BerthPo_BT.c BerthPo_Common.c BerthPo_Init.c BerthPo_main.c BerthPo_NB.c BerthPo_ParkStateJudge.c BerthPo_Sleep.c BerthPo_StatisMagneticDensity.c
  group Kernel/Bsp/Stm8/ADC
    ../../../SOURCE/Kernel/Bsp/Stm8/ADC/: BSP_ADC.c
  group Kernel/Bsp/Stm8/CLOCK
    ../../../SOURCE/Kernel/Bsp/Stm8/CLOCK/: BSP_CLOCK.c
  group Kernel/Bsp/Stm8/EEPROM
    ../../../SOURCE/Kernel/Bsp/Stm8/EEPROM/: BSP_EEPROM.c
  group Kernel/Bsp/Stm8/GPIO
    ../../../SOURCE/Kernel/Bsp/Stm8/GPIO/: BSP_GPIO.c
  group Kernel/Bsp/Stm8/I2C
    ../../../SOURCE/Kernel/Bsp/Stm8/I2C/: BSP_GPIO_I2C.c BSP_I2C.c
  group Kernel/Bsp/Stm8/RTC
    ../../../SOURCE/Kernel/Bsp/Stm8/RTC/: BSP_RTC.c
  group Kernel/Bsp/Stm8/SPI
    ../../../SOURCE/Kernel/Bsp/Stm8/SPI/: BSP_SPI.c
  group Kernel/Bsp/Stm8/STM8L15x_StdPeriph_Driver
    ../../../SOURCE/Kernel/Bsp/Stm8/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_it.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Kernel/Bsp/Stm8/TIM
    ../../../SOURCE/Kernel/Bsp/Stm8/TIM/: BSP_TIM.c
  group Kernel/Bsp/Stm8/UART
    ../../../SOURCE/Kernel/Bsp/Stm8/UART/: BSP_UART.c BSP_VMUART.c
  group Kernel/Drivers/Battry
    ../../../SOURCE/Kernel/Drivers/Battry/: Drivers_Battry.c
  group Kernel/Drivers/BC95
    ../../../SOURCE/Kernel/Drivers/BC95/: Drivers_BC95.c
  group Kernel/Drivers/Bluetooth/I410ES
    ../../../SOURCE/Kernel/Drivers/Bluetooth/I410ES/: Drivers_I410ES.c
  group Kernel/Drivers/LED
    ../../../SOURCE/Kernel/Drivers/LED/: Drivers_Led.c
  group Kernel/Drivers/RM3100
    ../../../SOURCE/Kernel/Drivers/RM3100/: Drivers_RM3100.c
  group Libraries/CRC
    ../../../SOURCE/Libraries/CRC/: Crc.c
  group Libraries/Delay
    ../../../SOURCE/Libraries/Delay/: Delay.c
  group Libraries/Queue
    ../../../SOURCE/Libraries/Queue/: Queue.c
  group Libraries/Sleep
    ../../../SOURCE/Libraries/Sleep/: Sleep.c
  group Libraries/StringOperation
    ../../../SOURCE/Libraries/StringOperation/: StringOperation.c
  group Libraries/TypeConvert
    ../../../SOURCE/Libraries/TypeConvert/: TypeConvert.c
