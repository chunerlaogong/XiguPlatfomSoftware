<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BerthPo_NBBC95B5.ewp</path>
    </project>
    <batchBuild />
</workspace>
