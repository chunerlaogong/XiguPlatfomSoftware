# IAR project BerthPo_SX1280.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: DEBUG; STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\..\..\SOURCE\App; ..\..\..\SOURCE\Kernel\Bsp\Stm8\include; ..\..\..\SOURCE\Libraries\include; ..\..\..\SOURCE\Kernel\Drivers\include; ..\..\..\SOURCE\Kernel\Bsp\Stm8\STM8L15x_StdPeriph_Driver\inc; ..\..\..\SOURCE\App\BerthPo_SX1280\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BerthPo_SX1280.srec
  ILINK.IlinkOutputFile: BerthPo_SX1280.out
  ILINK.IlinkIcfFile: linker\lnkstm8l052c6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP/BerthPo_SX1280
    ../../../SOURCE/App/BerthPo_SX1280/src/: BerthPo_SX1280_BottomValAdjustAdaptive.c BerthPo_SX1280_Common.c BerthPo_SX1280_Init.c BerthPo_SX1280_Main.c BerthPo_SX1280_ParkStateJudge.c BerthPo_SX1280_Sleep.c BerthPo_SX1280_StatisMagneticDensity.c
  group Kernel/BSP/ADC
    ../../../SOURCE/Kernel/Bsp/Stm8/ADC/: BSP_ADC.c
  group Kernel/BSP/CLOCK
    ../../../SOURCE/Kernel/Bsp/Stm8/CLOCK/: BSP_CLOCK.c
  group Kernel/BSP/EEPROM
    ../../../SOURCE/Kernel/Bsp/Stm8/EEPROM/: BSP_EEPROM.c
  group Kernel/BSP/GPIO
    ../../../SOURCE/Kernel/Bsp/Stm8/GPIO/: BSP_GPIO.c
  group Kernel/BSP/I2C
    ../../../SOURCE/Kernel/Bsp/Stm8/I2C/: BSP_GPIO_I2C.c
  group Kernel/BSP/RTC
    ../../../SOURCE/Kernel/Bsp/Stm8/RTC/: BSP_RTC.c
  group Kernel/BSP/SPI
    ../../../SOURCE/Kernel/Bsp/Stm8/SPI/: BSP_SPI.c
  group Kernel/BSP/STM8L15x_StdPeriph_Driver
    ../../../SOURCE/Kernel/Bsp/Stm8/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_it.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Kernel/BSP/TIM
    ../../../SOURCE/Kernel/Bsp/Stm8/TIM/: BSP_TIM.c
  group Kernel/BSP/UART
    ../../../SOURCE/Kernel/Bsp/Stm8/UART/: BSP_UART.c
  group Kernel/Drivers/Battry
    ../../../SOURCE/Kernel/Drivers/Battry/: Drivers_Battry.c
  group Kernel/Drivers/LED
    ../../../SOURCE/Kernel/Drivers/LED/: Drivers_Led.c
  group Kernel/Drivers/NFC
    ../../../SOURCE/Kernel/Drivers/NFC/: Drivers_NFC.c
  group Kernel/Drivers/RM3100
    ../../../SOURCE/Kernel/Drivers/RM3100/: Drivers_RM3100.c
  group Kernel/Drivers/SX1280
    ../../../SOURCE/Kernel/Drivers/SX1280/: Drivers_SX1280.c
  group Libraries/CRC
    ../../../SOURCE/Libraries/CRC/: Crc.c
  group Libraries/Delay
    ../../../SOURCE/Libraries/Delay/: Delay.c
  group Libraries/Queue
    ../../../SOURCE/Libraries/Queue/: Queue.c
  group Libraries/Sleep
    ../../../SOURCE/Libraries/Sleep/: Sleep.c
  group Libraries/StringOperation
    ../../../SOURCE/Libraries/StringOperation/: StringOperation.c
  group Libraries/TypeConvert
    ../../../SOURCE/Libraries/TypeConvert/: TypeConvert.c
