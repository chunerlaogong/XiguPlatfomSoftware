<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BerthPo_SX1280.ewp</path>
    </project>
    <batchBuild />
</workspace>
